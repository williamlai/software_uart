<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lib_sw_uart.ewp</path>
  </project>
  <batchBuild/>
</workspace>


